# Keil uVision project wspr_stm32f373.uvprojx, settings and files
target STM32F373CC (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F373CC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: wspr_stm32f373
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: src;..\STM32F37x_StdPeriph_Driver\inc;..\common_lib;..\STM32F3_USB-FS-Device_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./src/: main.c commands.c hal.c hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c ram_functions.c
  group lib
    ../STM32F37x_StdPeriph_Driver/src/: stm32f37x_adc.c stm32f37x_gpio.c stm32f37x_misc.c stm32f37x_sdadc.c stm32f37x_tim.c stm32f37x_rcc.c stm32f37x_pwr.c stm32f37x_exti.c
    ../common_lib/: si5351.c i2c_soft.c
    ../STM32F3_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
target STM32F373(release) (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F373CC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: as above
  output: wspr_stm32f373
  c flags: Optim=3 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 5.0.0, Device:Startup 1.3.0
